# IAR project Backup of Z20K11XM_OneshuntFoc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Z20K116M ZhiXin Z20K116M
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEV_Z20K116M
  ICCARM.CCIncludePath2: ..\SDK\Platform; ..\SDK\Platform\Core; ..\SDK\Platform\Devices; ..\SDK\Platform\Devices\Z20K116M\Inc; ..\SDK\StdDriver\Inc; ..\Solution\Motorcontrol\Modules\ctrl; ..\Solution\Motorcontrol\Modules\curve; ..\Solution\Motorcontrol\Modules\err; ..\Solution\Motorcontrol\Modules\est; ..\Solution\Motorcontrol\Modules\filter; ..\Solution\Motorcontrol\Modules\foc; ..\Solution\Motorcontrol\Modules\hal; ..\Solution\Motorcontrol\Modules\zxmath; ..\Solution\Motorcontrol\Modules\motor; ..\Solution\Motorcontrol\Modules\pid; ..\Solution\Motorcontrol\Modules\tc; ..\Solution\Motorcontrol\Modules\timer; ..\Solution\Motorcontrol\App; ..\Solution\Z20A8300A\inc; ..\Solution\Z20A8300A\confg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Z20K11XM_OneshuntFoc.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\SDK\Platform\Devices\Z20K116M\MakeRule\IAR\Z20K116M_flash.icf
  ILINK.IlinkAdditionalLibs: ..\Solution\Motorcontrol\Modules\lib\Z20K11XM_OneshuntFoc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Platform/Core
    ../SDK/Platform/Core/: arm_compat.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group Platform/Devices/Inc
    ../SDK/Platform/Devices/Z20K116M/Inc/: Z20K116M.h
  group Platform/Devices/Startup
    ../SDK/Platform/Devices/Z20K116M/Startup/IAR/: Z20K116M_startup.s
  group Solution/Motorcontrol/App
    ../Solution/Motorcontrol/App/: communication.c EventHandle.c Global_Structure.c Motor_Protection.c pmsm.c user_coeff.h user_pmsm.h
  group Solution/Motorcontrol/Modules/ctrl
    ../Solution/Motorcontrol/Modules/ctrl/: ctrl.c
  group Solution/Motorcontrol/Modules/curve
    ../Solution/Motorcontrol/Modules/curve/: ramp.c
  group Solution/Motorcontrol/Modules/err
    ../Solution/Motorcontrol/Modules/err/: err.c
  group Solution/Motorcontrol/Modules/filter
    ../Solution/Motorcontrol/Modules/filter/: iir_fo.c
  group Solution/Motorcontrol/Modules/foc
    ../Solution/Motorcontrol/Modules/foc/: Oneshunt.c
  group Solution/Motorcontrol/Modules/hal
    ../Solution/Motorcontrol/Modules/hal/: hal.c hal_cfg.h
  group Solution/Motorcontrol/Modules/pid
    ../Solution/Motorcontrol/Modules/pid/: pid.c
  group Solution/Motorcontrol/Modules/tc
    ../Solution/Motorcontrol/Modules/tc/: tc.c
  group Solution/Motorcontrol/Modules/timer
    ../Solution/Motorcontrol/Modules/timer/: timer.c
  group Solution/Motorcontrol/Modules/zxmath
    ../Solution/Motorcontrol/Modules/zxmath/: zxmathfp.c
  group Solution/Z20A8300A/confg
    ../Solution/Z20A8300A/confg/: Z20A8300A_Hal.c Z20A8300A_Init.c
  group Solution/Z20A8300A/inc
    ../Solution/Z20A8300A/inc/: Z20A8300A_Config.h Z20A8300A_Ctrl.h Z20A8300A_Diag.h Z20A8300A_If.h Z20A8300A_Reg.h Z20A8300A_Spi.h Z20A8300A_Type.h
  group Solution/Z20A8300A/src
    ../Solution/Z20A8300A/src/: Z20A8300A_Config.c Z20A8300A_Ctrl.c Z20A8300A_Diag.c Z20A8300A_Spi.c
  group StdDriver/Inc
    ../SDK/StdDriver/Inc/: Z20K11xM_adc.h Z20K11xM_can.h Z20K11xM_clock.h Z20K11xM_cmp.h Z20K11xM_crc.h Z20K11xM_dma.h Z20k11xM_drv.h Z20K11xM_ewdt.h Z20K11xM_flash.h Z20K11xM_gpio.h Z20K11xM_hwdiv.h Z20K11xM_i2c.h Z20K11xM_pmu.h Z20K11xM_regfile.h Z20K11xM_rtc.h Z20K11xM_spi.h Z20K11xM_srmc.h Z20K11xM_stim.h Z20K11xM_sysctrl.h Z20K11xM_tdg.h Z20K11xM_tim.h Z20K11xM_tmu.h Z20K11xM_uart.h Z20K11xM_wdog.h
  group StdDriver/Src
    ../SDK/StdDriver/Src/: Z20K11xM_adc.c Z20K11xM_can.c Z20K11xM_clock.c Z20K11xM_cmp.c Z20K11xM_crc.c Z20K11xM_dma.c Z20K11xM_drv.c Z20K11xM_ewdt.c Z20K11xM_flash.c Z20K11xM_gpio.c Z20K11xM_hwdiv.c Z20K11xM_i2c.c Z20K11xM_pmu.c Z20K11xM_regfile.c Z20K11xM_rtc.c Z20K11xM_spi.c Z20K11xM_srmc.c Z20K11xM_stim.c Z20K11xM_sysctrl.c Z20K11xM_tdg.c Z20K11xM_tim.c Z20K11xM_tmu.c Z20K11xM_uart.c Z20K11xM_wdog.c
